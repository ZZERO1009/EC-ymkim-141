# Keil uVision project LAB_PWM.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LAB_PWM_RCmotor +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: LAB_PWM_RCmotor.c
  group HAL
    ../../lib/: ecGPIO.c ecGPIO.h ecRCC.c ecRCC.h ecEXTI.c ecEXTI.h ecSysTick.c ecSysTick.h ecPWM.c ecPWM.h ecPinNames.c ecPinNames.h ecTIM.c ecTIM.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
